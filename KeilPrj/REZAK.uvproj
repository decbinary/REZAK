# Keil uVision project REZAK.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: REZAK +hex
  c flags: Optim=1
  c include: ..\Source\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\src;..\Source\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Source;..\Source\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\CoreSupport;..\Source\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Source\HD44780;..\Source\ENCODER;..\Source\SPI_EEPROM;..\Source\7SEG;..\Source\QUEUE;..\Source\HAL_KEYBOARD;..\Source\DISPLAY;..\Source\KEY;..\Source\HAL_DO;..\Source\CRC16;..\Source\CYCLE;..\Source\HAL_DI
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ../Source/: startup_stm32f10x_hd.s main.c stm32f10x_conf.h stm32f10x_it.c Test.c InitHAL.c
  group CMSIS
    ../Source/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Source/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group STD
    ../Source/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group HD44780
    ../Source/HD44780/: tm_stm32_hd44780.c
  group ENCODER
    ../Source/ENCODER/: rotary_encode.c Calibration.c
  group 7SEG
    ../Source/7SEG/: 7seg.c
  group SPI_EEPROM
    ../Source/SPI_EEPROM/: spi_ee.c READ_WRITE_DATA.c
  group HAL_KEYBOARD
    ../Source/HAL_KEYBOARD/: Key.c Keypad.c
  group QUEUE
    ../Source/QUEUE/: Queue.c PostMessage.c DlgProc.c
  group DISPLAY
    ../Source/DISPLAY/: display.c flick.c texterror.c w_strcpy.c
  group KEY
    ../Source/KEY/: KEY_R0.c KEY_CINPUT.c KEY_CL.c KEY_DISPLAY.c KEY_ERROR.c KEY_Number.c KEY_R1.c KEY_R2.c KEY_R3.c KEY_RD.c KEY_RPP.c KEY_RPS.c KEY_SK.c
  group HAL_DO
    ../Source/HAL_DO/: LED_DO.c OUT_DO.c
  group CRC16
    ../Source/CRC16/: CRC16.c
  group CYCLE
    ../Source/CYCLE/: CYCLE.c Motion.c zatl_stop.c
  group HAL_DI
    ../Source/HAL_DI/: OUT_DI.c
